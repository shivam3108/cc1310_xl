# IAR project collector_cc1310lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: collector_cc1310lp.out
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: collector_cc1310lp.ipcf
  group Configuration files
    Tools/: app.cfg
