<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\collector_cc1310lp.ewp</path>
    </project>
    <batchBuild />
</workspace>
